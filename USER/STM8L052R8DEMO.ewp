# IAR project STM8L052R8DEMO.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G4 STM8L151G4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\STM8L15x_StdPeriph_Driver\inc; ..\SYSTEM\Misc; ..\SYSTEM\SYS; ..\SYSTEM\RTC; ..\HARDWARE\TIMER; ..\HARDWARE\IWDG; ..\HARDWARE\HT1622
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8LDEMO.hex
  ILINK.IlinkOutputFile: STM8L052R8DEMO.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group ELAND
    ../ELAND/: eland_usart.c
  group HARDWARE/GPIO
    ../HARDWARE/GPIO/: gpio.c
  group HARDWARE/HT1622
    ../HARDWARE/HT1622/: ht162x.c
  group HARDWARE/IWDG
    ../HARDWARE/IWDG/: iwdg.c
  group HARDWARE/KEY
    ../HARDWARE/KEY/: key.c
  group HARDWARE/LCD_ELAND
    ../HARDWARE/LCD_ELAND/: lcd_eland.c
  group HARDWARE/RGBLED
    ../HARDWARE/RGBLED/: rgbled.c
  group HARDWARE/TIMER
    ../HARDWARE/TIMER/: timer.c
  group HARDWARE/USART
    ../HARDWARE/USART/: usart.c
  group STM8L15x_StdPeriph_Driver
    ../STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group SYSTEM/Misc
    ../SYSTEM/Misc/: timing_delay.c
  group SYSTEM/RTC
    ../SYSTEM/RTC/: rtc.c
  group SYSTEM/SYS
    ../SYSTEM/SYS/: syscfg.c
  group USER
    ./: main.c stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
